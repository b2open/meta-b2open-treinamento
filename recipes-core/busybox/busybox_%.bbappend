FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
            file://httpd.cfg \
            file://training_embeddedlinux.cfg \
            "
