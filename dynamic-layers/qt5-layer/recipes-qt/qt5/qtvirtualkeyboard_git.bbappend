PACKAGECONFIG = "lang-en_US lang-pt_BR lipi-toolkit qtquickcompiler"

