# Reduz o tempo de download e o tamanho do repositório, 
# buscando apenas os 10 commits mais recentes
BB_GIT_SHALLOW = "1"
BB_GIT_SHALLOW_DEPTH = "10"
