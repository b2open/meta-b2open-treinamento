PACKAGECONFIG:append = " nmtui modemmanager"
