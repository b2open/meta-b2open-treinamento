PACKAGECONFIG:append = " readline python tui"
